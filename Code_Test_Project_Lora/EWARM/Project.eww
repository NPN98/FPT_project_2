<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Code_Test_Project_Lora.ewp</path>
  </project>
  <batchBuild />
</workspace>
